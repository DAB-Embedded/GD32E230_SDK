# IAR project Project.ewp, settings and files
configuration GD32E23x (ARM, debug)
  General.OGChipSelectEditMenu: GD32E230x8 GD GD32E230x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: GD32E230
  ICCARM.CCIncludePath2: ..\..\Firmware\CMSIS; ..\..\Firmware\GD32E23x_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32E23x\Include; ..\..\Utilities; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    H:/cyy/fwlib/fw3235/GD32E23x_Firmware_Library/Examples/WWDGT/WWDGT_delay_feed/: gd32e23x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Doc
    ../: readme.txt
  group GD32E23x_EVAL
    ../../Utilities/: gd32e230c_eval.c
  group GD32E23x_Peripherals
    ../../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E23x/Source/IAR/: startup_gd32e23x.s
